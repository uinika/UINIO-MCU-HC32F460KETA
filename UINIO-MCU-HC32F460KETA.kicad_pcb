# Repository uinika/UINIO-MCU-HC32F460KETA

File README.md:

# UINIO-MCU-HC32F460KETA 核心板

[**UINIO-MCU-HC32F460KETA**](https://gitee.com/uinika/UINIO-MCU-HC32F460KETA) 是一款基于小华半导体 **HC32F460KETA-LQFP64** 型微控制器的核心板，该款微控制器的最大特点是支持 `1.8V ~ 3.6V` 的**宽电压范围**，和 `-40℃ ~ 105℃` 的**宽温度范围**。基于 **ARM Cortex-M4** 内核架构，最高工作频率可以达到 `200MHz`，内置有 **DSP** 数字信号处理器和 **FPU** 浮点运算单元。除此之外，还集成有 `512KB` 的 Flash 存储器，以及 `192KB` 的 SRAM 存储器。

## 设计概要

- 外部晶振电路，全部使用了打孔包地处理；
- 扩展了两路串联有自恢复保险丝的 `5V` 电源接口，整体采用覆铜处理，以提升接口的载流能力；
- 模拟电源引脚 `AVSS` 和 `AVCC` 都串联有对 `100Mhz` 高频杂散信号存在 `1KΩ` 阻抗的磁珠；
- 对调试下载接口 SWD 进行了前置处理，并且匹配了通信线序，可以方便快速的与 [**UINIO-DAPLink**](https://gitee.com/uinika/UINIO-DAPLink) 进行杜邦线连接；
- 引出了全部的 **52** 个 GPIO 端口，可以自由的使用 **8** 种常见的外设通信接口：

| 接口名称       | 数量  | 描述                                                                        |
| :------------- | :---- | :-------------------------------------------------------------------------- |
| **GPIO**       | 52 个 | `PAx`、`PBx`、`PCx`、`PDx`、`PHx` 一共五组。                                |
| **I2C**        | 3 组  | 支持 SMBus 协议。                                                           |
| **USART**      | 4 组  | 支持 ISO7816-3 协议。                                                       |
| **SPI**        | 4 组  | 支持 4 线式 SPI 模式和 3 线式时钟同步模式，支持全双工和只传送两种通信方式。 |
| **QSPI**       | 1 组  | 支持 `200Mbps` 高速访问的存储器控制模块。                                   |
| **I2S**        | 4 组  | 内置音频 PLL 支持音频级采样精度。                                           |
| **SDIO**       | 2 组  | 支持 SD/MMC/eMMC 格式。                                                     |
| **CAN**        | 1 组  | 支持 ISO11898-1 标准协议。                                                  |
| **USB 2.0 FS** | 1 组  | 内置 PHY，支持 Device/Host 模式。                                           |

## 参考技术文档

[UinIO.com 电子技术实验室](http://uinio.com/) 为 **UINIO-MCU-HC32F460KETA** 开源项目提供了如下一系列参考技术资料：

- [《UINIO-MCU-HC32F460KETA 核心板原理图》](http://uinio.com/archives/UINIO-MCU-HC32F460KETA/UINIO-MCU-HC32F460KETA-Schematic.pdf)
- [《交互式 BOM 物料清单与 PCB 版图在线预览》](http://uinio.com/archives/UINIO-MCU-HC32F460KETA/UINIO-MCU-HC32F460KETA-BOM.html)

## KiCad design UINIO-MCU-HC32F460KETA.kicad_pcb

Parts:
C1, C5, C6, C8, C9, C10, C12, C13, C17: 0.1uF; C_0603_1608Metric
C2, C3, C4, C7, C11: 1uF; C_0603_1608Metric
C14, C15, C16, C18: 10pF; C_0603_1608Metric
C19: 4.7uF; C_0603_1608Metric
D1: LED-RED; LED_0603_1608Metric
F1: Fuse; Fuse_1206_3216Metric
J1: Conn_01x14_Pin; PinHeader_1x14_P2.54mm_Vertical
J2, J3: Conn_01x24_Pin; PinHeader_1x24_P2.54mm_Vertical
J4: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J5, J6: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
L1, L2, L3, L4: 1K 100MHz; L_0603_1608Metric
R1, R2: 5.1K; R_0603_1608Metric
R3: 2K; R_0603_1608Metric
R4: 4.7K; R_0603_1608Metric
R5, R6, R7: 10K; R_0603_1608Metric
SW1: NRST; SW-SMD_4P-L4.2-W3.4-P2.15-LS4.7
U1: ME6211C33M5G; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BL
U2: HC32F460KETA-LQFP64; LQFP-64_L10.0-W10.0-P0.50-LS12.0-BL
USB1: USB_Type_C_16Pin
Y1: 32.768KHz; Crystal_SMD_3215-2Pin_3.2x1.5mm
Y2: 8MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
/AVCC: J3.22, L2.2, U2.19 (AVCC)
/AVCC/VREFH: J1.11, L4.2, U2.13 (AVCC/VREFH)
/AVSS: J3.23, L1.2, U2.18 (AVSS)
/AVSS/VREFL: J1.10, L3.2, U2.12 (AVSS/VREFL)
/NRST: C13.2, J1.5, R5.1, SW1.1, SW1.2, U2.7 (NRST)
/PA0: J1.12, U2.14 (PA0/ADC1_IN0)
/PA1: J1.13, U2.15 (PA1/ADC1_IN1)
/PA2: J1.14, U2.16 (PA2/ADC1_IN2)
/PA3: J3.24, U2.17 (PA3/ADC1_IN3)
/PA4: J3.21, U2.20 (PA4/ADC12_IN4)
/PA5: J3.20, U2.21 (PA5/ADC12_IN5)
/PA6: J3.19, U2.22 (PA6/ADC12_IN6)
/PA7: J3.18, U2.23 (PA7/ADC12_IN7)
/PA8: J3.1, U2.41 (PA8)
/PA9: J2.1, U2.42 (PA9/USBFS_VBUS)
/PA10: J2.2, U2.43 (PA10/USBFS_ID)
/PA11: J2.3, U2.44 (PA11/USBFS_DM)
/PA12: J2.4, U2.45 (PA12/USBFS_DP)
/PA13/JTMS_SWDIO: J2.5, J6.2, R7.1, U2.46 (PA13/JTMS_SWDIO)
/PA14/JTCK_SWCLK: J2.8, J6.1, R6.2, U2.49 (PA14/JTCK_SWCLK)
/PA15: J2.9, U2.50 (PA15/TDI)
/PB0: J3.15, U2.26 (PB0/ADC12_IN8)
/PB1: J3.14, U2.27 (PB1/ADC12_IN9)
/PB2: J3.13, U2.28 (PB2/PVD2EXINP)
/PB3: J2.14, U2.55 (PB3/JTDO_TRACESWO)
/PB4: J2.15, U2.56 (PB4/NJTRST)
/PB5: J2.16, U2.57 (PB5)
/PB6: J2.17, U2.58 (PB6)
/PB7: J2.18, U2.59 (PB7)
/PB8: J2.20, U2.61 (PB8)
/PB9: J2.21, U2.62 (PB9)
/PB10: J3.12, U2.29 (PB10)
/PB11/MD: C9.2, J2.19, J4.1, R4.1, U2.60 (PB11/MD)
/PB12: J3.9, U2.33 (PB12)
/PB13: J3.8, U2.34 (PB13)
/PB14: J3.7, U2.35 (PB14)
/PB15: J3.6, U2.36 (PB15)
/PC0: J1.6, U2.8 (PC0/ADC12_IN10)
/PC1: J1.7, U2.9 (PC1/ADC12_IN11)
/PC2: J1.8, U2.10 (PC2/ADC1_IN12)
/PC3: J1.9, U2.11 (PC3/ADC1_IN13)
/PC4: J3.17, U2.24 (PC4/ADC1_IN14)
/PC5: J3.16, U2.25 (PC5/ADC1_IN15)
/PC6: J3.5, U2.37 (PC6)
/PC7: J3.4, U2.38 (PC7)
/PC8: J3.3, U2.39 (PC8)
/PC9: J3.2, U2.40 (PC9)
/PC10: J2.10, U2.51 (PC10)
/PC11: J2.11, U2.52 (PC11)
/PC12: J2.12, U2.53 (PC12)
/PC13: J1.4, U2.2 (PC13)
/PD2: J2.13, U2.54 (PD2)
/PH2: J1.3, U2.1 (PH2)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, D1.1 (K), J1.2, J2.6, J2.22, J2.24, J3.11, J4.2, J4.3, J5.1, J5.3, J6.3, L1.1, L3.1, R1.2, R2.2, SW1.3, SW1.4, U1.2 (VSS), U2.31 (VSS), U2.47 (VSS), U2.63 (VSS), USB1.13 (GND), USB1.14 (GND), USB1.15 (GND), USB1.16 (GND), USB1.A1B12 (GND), USB1.B1A12 (GND)
unnamed: C14.2, Y2.4
unnamed: C18.2, Y2.2
unnamed: D1.2 (A), R3.1
unnamed: F1.1, J5.2, J5.4
unnamed: C15.2, U2.3 (PC14/XTAL32_OUT), Y1.2
unnamed: C16.2, U2.4 (PC15/XTAL32_IN), Y1.1
unnamed: U2.5 (PH0/XTAL_IN), Y2.3
unnamed: U2.6 (PH1/XTAL_OUT), Y2.1
unnamed: C12.2, U2.30 (VCAP_1)
unnamed: R1.1, USB1.A5 (CC1)
unnamed: R2.1, USB1.B5 (CC2)
VCC_3.3V: C1.2, C2.2, C3.2, C5.2, C6.2, C7.2, C8.2, C17.2, C19.2, J1.1, J2.7, J2.23, J3.10, J6.4, L2.1, L4.1, R3.2, R4.2, R5.2, R6.1, R7.2, U1.5 (VOUT), U2.32 (VCC), U2.48 (VCC), U2.64 (VCC)
VCC_5V: C4.2, C10.2, C11.2, F1.2, U1.1 (VIN), U1.3 (CE), USB1.A4B9 (VBUS), USB1.B4A9 (VBUS)

Notes on the sheet:
SWD 调 试 接 口
3.3V 线性稳压电路
32Pin 2.54mm 杜邦排针
HC32F460KETA-LQFP64 最小系统
USB Type-C 接口电路
5V 输出接口

Board: 2 copper layers, 73.4 x 42.9 mm, 48 parts (0 on the bottom side), 67 nets.

Other parts of the board:
HOLE**: Hole-2mm
HOLE**#2, HOLE**#3, HOLE**#4: Hole-2mm

## Commit log

2024-09-01 Release UINIO-MCU-HC32F460KETA version 1.0.0.
